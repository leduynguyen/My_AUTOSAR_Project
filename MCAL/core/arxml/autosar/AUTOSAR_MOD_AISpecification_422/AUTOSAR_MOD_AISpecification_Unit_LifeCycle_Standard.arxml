<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 autosar_4-2-2.xsd">
  <ADMIN-DATA>
    <LANGUAGE>EN</LANGUAGE>
    <USED-LANGUAGES>
      <L-10 L="EN" xml:space="default">English</L-10>
    </USED-LANGUAGES>
  </ADMIN-DATA>
  <AR-PACKAGES>
    <AR-PACKAGE>
      <SHORT-NAME>AUTOSAR</SHORT-NAME>
      <LONG-NAME>
        <L-4 L="EN">AUTOSAR</L-4>
      </LONG-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE>
          <SHORT-NAME>AISpecification</SHORT-NAME>
          <LONG-NAME>
            <L-4 L="EN">AISpecification</L-4>
          </LONG-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE>
              <SHORT-NAME>LifeCycleInfoSets</SHORT-NAME>
              <CATEGORY>STANDARD</CATEGORY>
              <REFERENCE-BASES>
                <REFERENCE-BASE>
                  <SHORT-LABEL>Units</SHORT-LABEL>
                  <IS-DEFAULT>false</IS-DEFAULT>
                  <IS-GLOBAL>false</IS-GLOBAL>
                  <BASE-IS-THIS-PACKAGE>false</BASE-IS-THIS-PACKAGE>
                  <PACKAGE-REF DEST="AR-PACKAGE">/AUTOSAR/AISpecification/Units</PACKAGE-REF>
                </REFERENCE-BASE>
              </REFERENCE-BASES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
